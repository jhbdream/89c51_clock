# Keil uVision project SEGMENT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SEGMENT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\segment;.\time;.\key;.\State_Machine;.\State
  group Source Group 1
    ./: STARTUP.A51
    ./segment/: segment.c main.c
    ./time/: time.c
    ./key/: key.c
    ./State_Machine/: State_Machine.c
    ./State/: Clock_State.c
